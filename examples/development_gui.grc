<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>6e6</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>var_agc_enabled</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>var_biast</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>biasT</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_if_atten_db</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value>if_atten_db</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_lna_atten_step</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>lna_atten_step</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>8</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_rf_freq</value></param>
<param><key>value</key><value>100e6</value></param>
<param><key>label</key><value>rf_freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e6</value></param>
<param><key>step</key><value>10000</value></param>
<param><key>stop</key><value>2000e6</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>var_rsp1_LNA_ON_OFF</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>RSP1 Only: LNA ON OFF</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>sdrplay_rspduo_source</key>
<param><key>id</key><value>Rsp_duo_source</value></param>
<param><key>tuner</key><value>1</value></param>
<param><key>rspduo_mode</key><value>1</value></param>
<param><key>agc_enabled</key><value>var_agc_enabled</value></param>
<param><key>antenna</key><value>'T1_50ohm'</value></param>
<param><key>bw</key><value>6000</value></param>
<param><key>biasT</key><value>var_biast</value></param>
<param><key>bcast_notch</key><value>False</value></param>
<param><key>dab_notch</key><value>False</value></param>
<param><key>dc_offset_mode</key><value>True</value></param>
<param><key>debug_enabled</key><value>True</value></param>
<param><key>device_serial</key><value>'0'</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>if_atten_db</key><value>var_if_atten_db</value></param>
<param><key>ifType</key><value>0</value></param>
<param><key>iq_balance_mode</key><value>True</value></param>
<param><key>lna_atten_step</key><value>var_lna_atten_step</value></param>
<param><key>lo_mode</key><value>1</value></param>
<param><key>rf_freq</key><value>var_rf_freq</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>var_rf_freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024*4</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>sdrplay_rsp1_source</key>
<param><key>id</key><value>sdrplay_rsp1_source_0</value></param>
<param><key>agc_enabled</key><value>var_agc_enabled</value></param>
<param><key>bw</key><value>6000</value></param>
<param><key>dc_offset_mode</key><value>True</value></param>
<param><key>debug_enabled</key><value>False</value></param>
<param><key>device_serial</key><value>'0'</value></param>
<param><key>if_atten_db</key><value>var_if_atten_db</value></param>
<param><key>ifType</key><value>0</value></param>
<param><key>iq_balance_mode</key><value>True</value></param>
<param><key>lna_atten_step</key><value>var_rsp1_LNA_ON_OFF</value></param>
<param><key>lo_mode</key><value>1</value></param>
<param><key>rf_freq</key><value>var_rf_freq</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>sdrplay_rsp1a_source</key>
<param><key>id</key><value>sdrplay_rsp1a_source_0</value></param>
<param><key>agc_enabled</key><value>var_agc_enabled</value></param>
<param><key>bw</key><value>6000</value></param>
<param><key>biasT</key><value>var_biast</value></param>
<param><key>bcast_notch</key><value>False</value></param>
<param><key>dab_notch</key><value>True</value></param>
<param><key>dc_offset_mode</key><value>True</value></param>
<param><key>debug_enabled</key><value>True</value></param>
<param><key>device_serial</key><value>'1806045E32'</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>if_atten_db</key><value>var_if_atten_db</value></param>
<param><key>ifType</key><value>0</value></param>
<param><key>iq_balance_mode</key><value>True</value></param>
<param><key>lna_atten_step</key><value>var_lna_atten_step</value></param>
<param><key>lo_mode</key><value>1</value></param>
<param><key>rf_freq</key><value>var_rf_freq</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>sdrplay_rsp2_source</key>
<param><key>id</key><value>sdrplay_rsp2_source_0</value></param>
<param><key>agc_enabled</key><value>var_agc_enabled</value></param>
<param><key>antenna</key><value>'A'</value></param>
<param><key>bw</key><value>6000</value></param>
<param><key>dc_offset_mode</key><value>True</value></param>
<param><key>debug_enabled</key><value>False</value></param>
<param><key>device_serial</key><value>'0'</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>if_atten_db</key><value>var_if_atten_db</value></param>
<param><key>ifType</key><value>0</value></param>
<param><key>iq_balance_mode</key><value>True</value></param>
<param><key>lna_atten_step</key><value>var_lna_atten_step</value></param>
<param><key>lo_mode</key><value>1</value></param>
<param><key>rf_freq</key><value>var_rf_freq</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>Rsp_duo_source</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp1_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp1a_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp2_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
