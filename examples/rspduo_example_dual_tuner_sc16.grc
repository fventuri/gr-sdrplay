<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>62500</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>sdrplay_rspduo_source</key>
<param><key>id</key><value>sdrplay_rspduo_source_0</value></param>
<param><key>agc_enabled</key><value>True</value></param>
<param><key>antenna</key><value>T1_50ohm</value></param>
<param><key>biasT</key><value>False</value></param>
<param><key>bcast_notch</key><value>False</value></param>
<param><key>dab_notch</key><value>False</value></param>
<param><key>dc_offset_mode</key><value>True</value></param>
<param><key>debug_enabled</key><value>False</value></param>
<param><key>device_serial</key><value>'0'</value></param>
<param><key>if_atten_db</key><value>40</value></param>
<param><key>iq_balance_mode</key><value>True</value></param>
<param><key>lna_atten_step</key><value>0</value></param>
<param><key>output_type</key><value>sc16</value></param>
<param><key>rf_freq</key><value>100e6</value></param>
<param><key>rspduo_mode</key><value>DT</value></param>
<param><key>sample_rate_non_single_tuner</key><value>62500</value></param>
<param><key>sample_rate_single_tuner</key><value>62500</value></param>
</block>
<connection><source_block_id>sdrplay_rspduo_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rspduo_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
